# Repository cliffgraph/FD-ARK

File README.md:

# FD-ARK
by Harumakkin. 2023/08/29

**fig.1 FD-ARK-06A**

## What's is this
FD-ARKは、FDDコントローラー＆FDDエミュレーターです。エミュレーターもしくはコントローラの二つの機能を持ち、基板上にある MODE SWによってどちらの機能を使用するかを利用者が選択します。

### （A）FDDコントローラーとしての機能
- MODE SWを"CTRL"にして電源を入れると、FD-ARKはFDDコントローラーとして動作します
- FD-ARKにFDD（フロッピーディスクドライブ）を接続し、2DDフロッピーディスク[^1]から全トラックデータを読み込んでSDカードに保存することができます。保存したデータをフロッピーに書き戻すこともできます。
- SDカード内でフロッピーディスク毎にフォルダ分けする機能がありますで、複数のフロッピーディスクを読み込、SDカードに保存することができます。
- 保存するフォルダは番号で管理されており、ロータリーエンコーダをつまんで回すことでその番号を選ぶことができます。
[^1]:2HDフロッピーディスクには対応していません。

**fig.2 FD-ARK-06A with floppy disk drive**

### （B）FDDエミュレーターとしての機能
- MODE SWを"EMU"にして電源を入れると、FD-ARKはFDDエミュレーターとして動作します
- MSX turboR[^2]で、内臓FDDを取り外してFD-ARKを接続することで、FDDの代わりとして機能します。
- FDデータは、FDDコントローラー機能であらかじめSDカード内に保存しておく必要があります。
- MSX本体にアクセスさせるFDデータは、ロータリーエンコーダを回して指定できます。
[^2]:FS-A1STのみで動作確認を行っています。MSX2+ FS-A1WX/FS-A1WSX, MSX turboR FS-A1GT でも動作するはずです。

**fig.3 FD-ARK-06A with MSXturboR**

## 利用時の注意事項
- MODE SWに切り替えはFD-ARKの電源が切れているときのみ行うことができます。
- また、MSX本体にFD-ARKをつないだままFDDコントローラーに切り替えたり、FDDをFD-ARKをつないだままFDDエミュレーターに切り替えないでください。MSX本体やFDD、FD-ARKが破損する可能性があります。
- MicroSDカードはFATで形式でフォーマットしてください
- イレギュラーなことへの対処はあまり対応していません、FDDアクセス中にフロッピーディスクを抜くとか、SDカードをアクセス中に抜くなどを行うと、FD-ARKやMSX本体がフリーズしたりします。

## FD-ARKを作る
部品表にある部品の収集、プリント基板の製造、組み立て、ファームウェアの書き込みの作業が必要です。完成品はありません。
PCBを発注できて、SOPチップをはんだ付けで来て、Raspberry Pi Picoにu2fファイルを書き込みができる必要があります。

## FD-ARKを使う
### フロッピーディスクを読み込んでＳＤカードに保存する方法(FDDコントローラー)
1. FD-ARKのMODE SWを "CTRL" に切り替えます
1. FD-ARKに、MicroSDカードを装着します。MicroSDカードはWindowsPCなどで事前に FAT 形式でフォーマットしてください。
1. FDDを装着します。FDDは、J2、J3、J4のいずれかのコネクタに接続します。使用実績のあるFDDとその接続箇所はTable 1を参照ンしてください。
1. FD-ARKに、DC5V電源（センタープラス）を接続して電源を入れます
1. LCD画面には、
0001(no file
[←FD][→FD]
と表示されているはずです。
[←FD] の部分が[(空欄)]で表示されている場合は、SD-WPスイッチをOFFに切り替えます。[←FD]が表示されるはずです。
SD-WPスイッチは、SDカードへの書込禁止／許可を切り替えるスイッチです。
1. 読み込みたいフロッピーディスクをFDDへ挿入します。念のためフロッピーディスクのライトプロテクトはＯＮしてください
1. ロータリーエンコーダーを回してフロッピーディスクから読み込んだデータを格納するフォルダを決めます。0001から9999まで選択できます。
1. [←FD] スイッチ（INSERTとシルク印字されているスイッチ）を押します。FDDから読み込みが開始されます。
1. 両面80トラック(全160トラック)の読み込みが完了すると、完了音が鳴り、Completed と表示されます。
1. EJECTとシルク印字されているスイッチを押して、元の画面に戻ります。
1. 格納されたフォルダでは、画面に"FD-DATA"と表示されます。
ex) 0001 FD-DATA
1. 別のFDを読み込みたい場合は、別のフォルダを選択して同様の操作を行います。（どの番号にどのF\フロッピーを読み込んだかは別途メモしておいてください）
1. SDカードをWindowsPCなどで参照すると、\FD-ARK\XXXX フォルダが生成されています。XXXXは保存先に選択したフォルダの番号です。
1. \FD-ARK\XXXX フォルダ内には、COMMENT.TXT と複数のTKnnnn-n.DAT ファイルが生成されています。
1. COMMENT.TXTはLCDに表示されるフォルダ名称が格納されています。編集することができます（半角英数字のみ）。COMMENT.TXTファイルに書き込まれた内容がLCDに表示されるようになります。
### フロッピーディスクへ書き戻す方法(FDDコントローラー)
1. ライトプロテクトをOFFしたフロッピーディスクをFDDに入れます。
1. フロッピーディスクへ書き込むディスクイメージを選択します。
1. [→FD]スイッチ（RETURNとシルク印字されているスイッチ）を押します。FDDへの書き込みが開始されます。

**Table 1. FDDコントローラー・モードで実績のあるFDD**
||型番|メーカー|備考|
|:-:|:-|:-|:-|
|J2|YD-702D-6238D|YE DATA|J8をFDDの電源につなげる|
|J2|D353M3D|MITSUMI|J8をFDDの電源につなげげる|
|J3|EME213MU|Matsushita Electronic Components|FFC 1.25mmピッチ,24ピン,電極逆面を使用する|
|J4|YD-702J-6637J|YE DATA|FFC 1.00mmピッチ,26ピン,電極逆面を使用する||

### MSX本体に接続してフロッピーディスクの代わりとして使用する(FDDエミュレータ)
1. FD-ARKのMODE SWを "EMU" に切り替えます
1. FD-ARKに、MicroSDカードを装着します。事前にFDDコントローラーモードでなにがしかのフロッピーディスクイメージを保存しておく必要があります。
1. FD-ARKのJ5とMSX本体をフラットフレックスケーブルで接続します。動作確認を行った機種はFS-A1STのみです
1. FD-ARKに、DC5V電源（センタープラス）を接続して電源を入れます
1. ロータリーエンコーダーを回して、使用したいフロッピーディスクイメージを選択します。[INSERT]スイッチを押すと選択が確定します（フロッピーディスクをドライブに入れている状態になる）。INSERTされているディスクイメージは番号の前に"*" が表示されます。この状態でロータリーエンコーダーを回して別の番号を表示しても、"*"が表示されているフロッピーディスクイメージがそのまま使用されます。
ex) *0001 FD-DATA
1. [EJECT]スイッチを押すと、フロッピーディスクを取り出した状態にすることができます。
1. MSX本体の電源を入れます。
1. フロッピーディスクイメージを選択していて、そのイメージがブート可能な内容ならそのフロッピーディスクの内容が起動するはずです。

### MicroSDカード
FDDコントローラーモードでディスクイメージをSDカードに保存すると、SDカードにはFD-ARKフォルダが作成され、ディスクイメージはそのフォルダ内に作成される番号フォルダに下記込まれます
```
FD-ARK/
  ├ 0001/
  ├ 0002/
      :
```
番号フォルダ内には、160個のTKnnnn-n.DATファイルとCOMMENT.TXTファイルが格納されています。
１トラックにつき１つのファイルで、TKnnnn-n.DATはフロッピー１トラック分のデータですnnnnはトラック番号。-nはサイド番号です。
.DATファイルの先頭には少しの管理情報と、FDDのREAD DATA端子から出力されているデータを4MHzでサンプリングした情報がそのまま格納されています。
セクタ構造など一切確認作業を行わず生の出力データをそのまま保存しているので.DATファイルの内容が正しいかどうかの保障はありません。

## LICENSEと利用に関する注意事項
1. FD-ARKのファームウェアとそのソースコード、回路図データおよび資料ファイルは MIT License で配布されます。ただし、FD-ARK は、FatFsを使用しています。FatFsのソースコードの扱いに関してはFatFsのLICENSEに従ってください。
2. 本作品は同人ハードウェア＆ソフトウェアです。本作品の設計およびソフトウェアは品質を保証していません。MSX本体、フロッピーディスクドライブ、およびフロッピーディスクとそのデータが故障、破損したとしても自身で責任を負える方のみ本作品をご利用ください。特にハードウェアの製作を伴いますのでリスクがあります。製作の腕に自身のある方のみご利用ください。
3. 本作品の設計資料とソースコードの改変や改造、また、別の作品への利用、商用利用は自由です。ただし、1. 2.の制限を超える利用は各自でその責任と義務を負ってください。

## FD-ARKが使用しているソフトウェア
### FatFs
Copyright (C) 20xx, ChaN, all right reserved.
http://elm-chan.org/fsw/ff/00index_e.html

## 余談
1. FD-ARK製作の経緯：
当初、FDX68シールドという作品がBOOTHで売られていて[^3]、その装置はフロッピーディスクを読みだすことができ、またFDDエミュレータとして使用することもできるものらしいという漠然とした知識だけありました。そういう物があるのかぐらいに捉えていて、自身は必要性を感じていませんでした。しかしある時にふとゲーム保存協会のツイート[^4]が目にとまり、国立国会図書館@NDLJPフロッピーディスク長期保存対策に関する調査報告書というの知りました。これには様々な理由でフロッピーディスクは劣化するものであり、劣化するとフロッピーディスクは使用できなくなってしまうと書かれていました。自身が所有しているMSXに関するフロッピーディスクは30年を超えている物が多く、報告書との出会いは、結果、これらフロッピーディスクに危機感を募らせてしまうことになりました。FDX68シールド、ぜひとも欲しいとなったわけですが、いつも売り切れでこれがなかなか購入できません。調査報告書では似たようなツールにKryoFluxというものを紹介していました。それが公式ページから今でも購入可能と書かれていたので、購入してみることにしました。ただちゃんと調べてから購入すれば良かったのですが、てっきりFDX68のようにKryoFluxにもFDDエミュレータの機能があると思い込んでいてこれが失敗でした。発注後に取説書読んでそれに気が付いたわけですが、同時にFDDって意外とシンプルな仕組みなんだとその時に知りました。これならKryoFluxで読み込んだデータを使用するFDDエミュレータを自分でも作れるだろう、いや作ってしまえと思うに至りました。しっかり作ろうとすると細部が大変になりますのでフロッピーディスクのイメージ化機能もいっしょに作ってしまえば、データフォーマットも独自定義できるしもっと楽に作れると思い、結果、今回のFD-ARKになりました。KryoFluxはKryoFluxで、FD-ARKが失敗した時のためにとフロッピーディスクのイメージ化に今でも使用しています。また、FD-ARKで読み出して、そして書き出した後に、正しく読み書きできているかをKryoFluxでチェックするなんてことに使用しています。
自分自身が所有するフロッピーディスクのためだけに作成したので、3.5"2DD以外の対応は考えていません。
[^3]: https://booth.pm/ja/items/4451666
[^4]: https://twitter.com/gamepres/status/1648638490765295619

2. FDアーカイバを意味した"FD-ARC"と命名するつもりが、間違って"FD-ARK"と名付けてしまいました。ただ、"ARK"は聖書に出てくる十戒石板をおさめた箱を意味するので、大事な物をしまっておくという意味で FD-ARK のままとしました。

## KiCad design FddPurserPcb/FddPurserPcb.kicad_pcb

Parts:
C1, C2, C4: 104; C_Rect_L4.5mm_W3.5mm_P2.54mm
C3: 105; C_Rect_L4.5mm_W3.5mm_P2.54mm
C5: 100uF; CP_Radial_D8.0mm_P3.50mm
D1: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
D2, D3: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4
IC1: TC74HC07AF_F_; SOIC127P780X190-14N; Manufacturer_Part_Number TC74HC07AF(F)
IC2: MCP23S08-E_SS; SOP65P780X200-20N; Manufacturer_Part_Number MCP23S08-E/SS
J1: HIF3BA-34PA-2.54DS_71_; HIF3BA34PA254DS71; Manufacturer_Part_Number HIF3BA-34PA-2.54DS(71)
J2: HIF3BA-34PA-2.54DSA_71_; SHDR34W60P254_2X17_6250X850X2730P; Manufacturer_Part_Number HIF3BA-34PA-2.54DSA(71)
J3: 24FE-BT-VK-N; 24FEBTVKN; Manufacturer_Part_Number 24FE-BT-VK-N
J4: HLW26S-2C7LF; HLW26S2C7LF; Manufacturer_Part_Number HLW26S-2C7LF
J5: 24FE-ST-VK-N; 24FESTVKN; Manufacturer_Part_Number 24FE-ST-VK-N
J6: AE-LLCNV-LVCH16T245; DIP-48_W15.24mm_Socket_LongPads
J7: MJ-179PH; MJ179PH_N; Manufacturer_Part_Number MJ-179PH
J8: S3B-XH-A_LF__SN_; S3BXHALFSN; Manufacturer_Part_Number S3B-XH-A(LF)(SN)
JP1: Jumper_2_Open; PinSocket_1x02_P2.54mm_Vertical
LCD1: AQM1602Y-NLW-FBW; AQM1602Y-NLW
LS1: PKM13EPYH4000-A0; PKM13EPYH4002-B0; Manufacturer_Part_Number PKM13EPYH4000-A0
Q1: 2N7000; TO-92_Inline
R1, R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4: 4.7k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R7, R8, R9, R10, R11: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
S1, S2, S3: TVDP01-G73BB; TVDP01G73BB; Manufacturer_Part_Number TVDP01-G73BB
S4, S5: SS12D00G3; Manufacturer_Part_Number SS12D00G3
U1: RaspberryPi Pico; RPi_Pico_SMD_TH
U2: EC12E2420801; Manufacturer_Part_Number EC12E2420801
U3: Micro SD Card Socket
U4: AE-XC9306-3V3; AE-XC9306-xVx

Connections:
2DIR: J6.44, U1.25 (GPIO19)
+3V3: C1.2, IC2.6 (~RESET), IC2.20 (VDD), J6.1, J6.2, J6.48, JP1.2 (B), U3.1 (3V3), U4.3 (OUT)
+5V: C3.2, C4.2, C5.1, D1.1 (K), IC1.14 (VCC), J3.1, J3.2, J3.4, J3.5, J4.1, J4.3, J4.5, J6.3, J6.4, J7.1, J8.1, LCD1.5 (VDD), LS1.1 (+), R1.1, R5.1, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, U1.40 (VBUS), U4.1 (IN)
/HIGH DENSITY: J4.9
/LCD_SCL: LCD1.8 (SCL), U1.22 (GPIO17)
/LCD_SDA: LCD1.7 (SDA), U1.21 (GPIO16)
GND: C1.1, C4.1, C5.2, D2.1 (K), D3.1 (K), IC1.7 (GND), IC2.4 (A1), IC2.5 (A0), IC2.9 (VSS), J1.7, J1.9, J1.11, J1.13, J1.15, J1.17, J1.19, J1.21, J1.23, J1.25, J1.27, J1.29, J1.31, J1.33, J2.7, J2.9, J2.11, J2.13, J2.15, J2.17, J2.19, J2.21, J2.23, J2.25, J2.27, J2.29, J2.31, J2.33, J3.7, J3.8, J3.10, J3.15, J3.17, J4.15, J4.17, J4.19, J4.21, J4.23, J4.25, J5.7, J5.8, J5.10, J5.15, J5.17, J6.5, J6.6, J6.23, J6.24, J6.25, J6.26, J6.43, J6.45, J7.2, J8.3, LCD1.6 (VSS), LCD1.K, Q1.1 (S), S1.3 (NO_1), S2.3 (NO_1), S3.3 (NO_1), S4.2 (COM), S5.2 (COM), U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U2.3 (C), U3.6 (GND), U4.2 (GND)
unnamed: D1.2 (A), LS1.2 (-), Q1.3 (D), R1.2
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R3.2
unnamed: IC2.12 (GP0), S3.1 (COM_1)
unnamed: IC2.13 (GP1), S2.1 (COM_1)
unnamed: IC2.14 (GP2), S1.1 (COM_1)
unnamed: IC2.15 (GP3), U2.2 (B)
unnamed: IC2.16 (GP4), U2.1 (A)
unnamed: IC2.17 (GP5), S4.3 (NO)
unnamed: IC2.18 (GP6), R3.1
unnamed: IC2.19 (GP7), R4.1
unnamed: JP1.1 (A), U1.36 (3V3)
unnamed: C2.2, LCD1.3 (CAP1N)
unnamed: C2.1, LCD1.4 (CAP1P)
unnamed: LCD1.A, R5.2
unnamed: C3.1, LCD1.2 (VOUT), LCD1.9 (~RES)
unnamed: Q1.2 (G), R2.2
unnamed: S5.3 (NO), U1.24 (GPIO18)
unnamed: R2.1, U1.1 (GPIO0)
SPI_CLK: IC2.1 (SCK), U1.4 (GPIO2), U3.4 (CLK)
SPI_CS_IO: IC2.7 (~CS), U1.2 (GPIO1)
SPI_CS_SD: U1.7 (GPIO5), U3.2 (CS)
SPI_MISO: IC2.3 (SO), U1.6 (GPIO4), U3.5 (MISO)
SPI_MOSI: IC2.2 (SI), U1.5 (GPIO3), U3.3 (MOSI)
~1OE: J6.47, U1.19 (GPIO14)
~2OE: J6.46, U1.20 (GPIO15)
~FDC_DISK_CHANGE: IC1.10 (5Y), J1.34, J5.24
~FDC_INDEX: IC1.2 (1Y), J1.8, J5.23
~FDC_READY: IC1.12 (6Y), J5.6
~FDC_READ_DATA: IC1.4 (2Y), J1.30, J5.11
~FDC_TRACK00: IC1.6 (3Y), J1.26, J5.13
~FDC_WRITE_PROTECT: IC1.8 (4Y), J1.28, J5.12
~FD_DIRECTION: J1.18, J2.18, J3.19, J4.12, J5.19, J6.19
~FD_DISK_CHANGE: J2.34, J3.24, J4.6, J6.10, R10.1
~FD_DRIVE_SELECT_1: J1.12, J2.12, J3.22, J4.4, J5.22, J6.21
~FD_INDEX: J2.8, J3.23, J4.2, J6.14, R6.1
~FD_MODE_SELECT: J1.2, J2.2, J4.13, J6.22
~FD_MOTOR_ON_1: J1.16, J2.16, J3.20, J4.10, J5.20, J6.20
~FD_READY: J3.6, J4.8, J6.9, R11.1
~FD_READ_DATA: J2.30, J3.11, J4.24, J6.13, R9.1
~FD_SIDE1: J1.32, J2.32, J3.9, J4.26, J5.9, J6.15
~FD_STEP: J1.20, J2.20, J3.18, J4.14, J5.18, J6.18
~FD_TRACK00: J2.26, J3.13, J4.20, J6.12, R7.1
~FD_WRITE_DATA: J1.22, J2.22, J3.16, J4.16, J5.16, J6.17
~FD_WRITE_GATE: J1.24, J2.24, J3.14, J4.18, J5.14, J6.16
~FD_WRITE_PROTECT: J2.28, J3.12, J4.22, J6.11, R8.1
~PICO_DIRECTION: J6.30, U1.12 (GPIO9)
~PICO_DISK_CHANGE: IC1.11 (5A), J6.39, U1.26 (GPIO20)
~PICO_DRIVE_SELECT_1: J6.28, U1.10 (GPIO7)
~PICO_INDEX: IC1.1 (1A), J6.35, U1.32 (GPIO27_ADC1)
~PICO_MODE_SELECT: J6.27, U1.9 (GPIO6)
~PICO_MOTOR_ON_1: J6.29, U1.11 (GPIO8)
~PICO_READY: IC1.13 (6A), J6.40, U1.34 (GPIO28_ADC2)
~PICO_READ_DATA: IC1.3 (2A), J6.36, U1.31 (GPIO26_ADC0)
~PICO_SIDE1: J6.34, U1.17 (GPIO13)
~PICO_STEP: J6.31, U1.14 (GPIO10)
~PICO_TRACK00: IC1.5 (3A), J6.37, U1.29 (GPIO22)
~PICO_WRITE_DATA: J6.32, U1.15 (GPIO11)
~PICO_WRITE_GATE: J6.33, U1.16 (GPIO12)
~PICO_WRITE_PROTECT: IC1.9 (4A), J6.38, U1.27 (GPIO21)

Notes on the sheet:
PROTECT SW
FFC 24P FDD (PanasonicFS-A1ST)
FOR FDD POWER
FFC 26P FDD(YD-702J-6637J)
FFC 24P FDC(MSXtR)
ボックスヘッダ34P
MODE SW

Board: 2 copper layers, 154.9 x 102.2 mm, 46 parts (0 on the bottom side), 66 nets.

## Commit log

2023-08-13 the first commit: FD-ARK's PCB data and firmware source code.
2023-08-29 #1 部品表の誤記を修正した。ついでにREADME.mdの、開発経緯の文章も修正した
